Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0], RevitIdentifiers [ContentGUID: f9e5a772-afb4-4655-b409-44a608f65106, VersionGUID: 84327f1e-ae92-4a43-98d5-4e3186b5c98f, NumberOfSaves: 0], CoordinateReference [CoordinateBase: Shared Coordinates, ProjectSite: Default Site]
File name: 142548.ifc
Time: 2026-05-19T17:14:48+05:30
Written by: ODA SDAI 24.6
Made in: Autodesk Revit 24.3.30.11 (ENU) - IFC 24.3.30.11

# IfcProject, 0001
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 mm

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1

# IfcBuildingStorey: Level:8mm Head (2)
Pset_AirSideSystemInformation - sets with these values: 2
Name | LongName = Name | Elevation (mm)
Level 1 | Level 1 | 0
Level 2 | Level 2 | 4000

# IfcDistributionPort (15)
Description: Flow; FlowDirection: SOURCE
Name
OutPort_432352_1
OutPort_432352_2
OutPort_432352_4
OutPort_432352_5
OutPort_432352_6
OutPort_432352_7
OutPort_432352_8
OutPort_432352_9
OutPort_432352_10
OutPort_432352_11
OutPort_432352_12
OutPort_432352_13
OutPort_432352_14
OutPort_432352_15
OutPort_432352_16

# IfcFlowTerminal: PowerDrain_SK2-902G_In-line_pit:SK2-902 In-line pit (0.5m), PowerDrain_SK2-902G_In-line_pit:SK2-902 In-line pit (0.5m):432352
In: Level 1
Type - Description: ACO SK2-902 In-line pit (0.5m); PredefinedType: USERDEFINED; Material: PE, Black, Iron, Ductile, polymer concrete
Type - Pset_ManufacturerTypeInformation - Manufacturer: ACO
Pset_DistributionFlowElementCommon - Reference: SK2-902 In-line pit (0.5m); sets with these values: 2
PowerDrain S200K Schedule - item_description: ACO SK2-902 In-line pit (0.5m); code_supplier_article_C_ANZRS: 142548; net_mass_S_ANZRS: 32.3 kg; URL: https://acodrain.com.au/products/; productrange: PowerDrain; Manufacturer: ACO; Model: SK2-902 In-line pit (0.5m); content_creator_C_ANZRS: ACO Technology Centre, INDIA; OmniClass Title: Rainwater Removal; OmniClass Number: 23.70.50.24; code_specification_URL_C_ANZRS: https://acodrain.com.au/trench-drains/powerdrain/; info_commercial_C_ANZRS: https://acodrain.com.au/trench-drains/powerdrain/; info_technical_C_ANZRS: https://acodrain.com.au/trench-drains/powerdrain/

# IfcFlowTerminal: ZZZ_do not use_PF_ST_S200K_In-line pit_gratings_ACO:std(nested), ZZZ_do not use_PF_ST_S200K_In-line pit_gratings_ACO:std(nested):432354
In: Level 1
Type - Description: ACO PowerDrain_S200K_gratings; Material: Iron, Ductile
Type - Pset_ManufacturerTypeInformation - Manufacturer: ACO
Pset_DistributionFlowElementCommon - Reference: std(nested); sets with these values: 2
PowerDrain S200K Schedule - item_description: S200K Iron Intercept Heelsafe® Anti-Slip grate (0.5m); code_supplier_article_C_ANZRS: 142685; net_mass_S_ANZRS: 8.7 kg; URL: https://acodrain.com.au/; productrange: PowerDrain; Manufacturer: ACO; Model: PowerDrain_S200K_gratings; LOD: LOD 300; content_creator_C_ANZRS: ACO Technology Centre, INDIA; OmniClass Title: Rainwater Removal; OmniClass Number: 23.70.50.24; code_specification_URL_C_ANZRS: https://acodrain.com.au/products/powerdrain/#details; info_commercial_C_ANZRS: https://acodrain.com.au/products/powerdrain/#details; info_technical_C_ANZRS: https://acodrain.com.au/products/powerdrain/#details
